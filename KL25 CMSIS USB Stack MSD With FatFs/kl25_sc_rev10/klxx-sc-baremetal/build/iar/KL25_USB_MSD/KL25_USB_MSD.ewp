# IAR project KL25_USB_MSD.ewp, settings and files
configuration FLASH_128KB (ARM, debug)
  General.OGChipSelectEditMenu: MKL26Z128xxx4 Freescale MKL26Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: IAR; FREEDOM; SD_DISK_ENABLE
  ICCARM.CCIncludePath2: ..\..\..\src\projects\KL25_USB_MSD; ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\i2c; ..\..\..\src\drivers\llwu; ..\..\..\src\drivers\lptmr; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\pmc; ..\..\..\src\drivers\rcm; ..\..\..\src\drivers\rtc; ..\..\..\src\drivers\smc; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\wdog; ..\..\..\src\drivers\cmp; ..\..\..\src\platforms; ..\; ..\..\..\src\projects\KL25_USB_MSD\CMSIS USB Stack\inc; ..\..\..\src\projects\KL25_USB_MSD\CMSIS USB Stack\Porting use; ..\..\..\src\projects\KL25_USB_MSD\SPI_SDCard; ..\..\..\src\projects\KL25_USB_MSD\FATFS; ..\..\..\src\projects\KL25_USB_MSD\FATFS\fsl_sd_disk
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: KL25_USB_MSD.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\config files\128KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH_64KB (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKL25Z128xxx4 Freescale MKL25Z128xxx4
  ICCARM.CCDefines: IAR; FREEDOM
  ICCARM.CCIncludePath2: ..\..\..\src\projects\KL25_USBCDC; ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\llwu; ..\..\..\src\drivers\lptmr; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\pmc; ..\..\..\src\drivers\rcm; ..\..\..\src\drivers\rtc; ..\..\..\src\drivers\smc; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\wdog; ..\..\..\src\drivers\cmp; ..\..\..\src\platforms; ..\
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: platinum_freedom.srec
  ILINK.IlinkIcfFile: ..\config files\64KB_Pflash.icf
configuration FLASH_32KB (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKL25Z128xxx4 Freescale MKL25Z128xxx4
  ICCARM.CCDefines: IAR; FREEDOM
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: platinum_freedom.srec
  ILINK.IlinkIcfFile: ..\config files\32KB_Pflash.icf
  group common
    ../../../src/common/: alloc.c assert.c assert.h common.h io.c io.h memtest.c memtest.h printf.c queue.c queue.h startup.c startup.h stdlib.c stdlib.h uif.c uif.h
  group cpu
    ../../../src/cpu/: arm_cm0.c arm_cm0.h crt0.s start.c start.h sysinit.c sysinit.h vectors.c vectors.h
  group cpu/headers
    ../../../src/cpu/headers/: MKL25Z4.h
  group drivers/cmp
    ../../../src/drivers/cmp/: cmp.c cmp.h
  group drivers/i2c
    ../../../src/drivers/i2c/: i2c.c i2c.h
  group drivers/llwu
    ../../../src/drivers/llwu/: llwu.c llwu.h
  group drivers/lptmr
    ../../../src/drivers/lptmr/: lptmr.c lptmr.h
  group drivers/mcg
    ../../../src/drivers/mcg/: mcg.c mcg.h
  group drivers/pmc
    ../../../src/drivers/pmc/: pmc.c pmc.h
  group drivers/rcm
    ../../../src/drivers/rcm/: rcm.c rcm.h
  group drivers/rtc
    ../../../src/drivers/rtc/: rtc.c rtc.h
  group drivers/smc
    ../../../src/drivers/smc/: smc.c smc.h
  group drivers/uart
    ../../../src/drivers/uart/: uart.c uart.h
  group IAR
    ../config files/: 128KB_Pflash.icf 16KB_RAM.icf 32KB_Pflash.icf 4KB_RAM.icf 64KB_Pflash.icf 8KB_RAM.icf
    ../: iar.h
  group platforms
    ../../../src/platforms/: freedom.h
  group project
    ../../../src/projects/KL25_USB_MSD/: fatdemo.c fatdemo.h isr.h main.c
  group project/CMSIS USB Stack
    ../../../src/projects/KL25_USB_MSD/CMSIS USB Stack/Porting use/: usb_config.h usb_lib.c usbd_KL25.c
    ../../../src/projects/KL25_USB_MSD/CMSIS USB Stack/src/: usbd_core.c usbd_core_msc.c usbd_msc.c
  group project/FATFS
    ../../../src/projects/KL25_USB_MSD/FATFS/: ccsbcs.c diskio.c diskio.h ff.c ff.h ffconf.h
    ../../../src/projects/KL25_USB_MSD/FATFS/fsl_sd_disk/: fsl_sd_disk.h fsl_sdspi_disk.c
  group project/SPI_SDCard
    ../../../src/projects/KL25_USB_MSD/SPI_SDCard/: fsl_sdcard_spi.c fsl_sdcard_spi.h fsl_sdmmc_card.h SPI_kinetis.c SPI_kinetis.h
